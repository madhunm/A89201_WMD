# Keil uVision project FieldOrientedControl_ExampleProject.uvprojx, settings and files
target Debug (6120000::V6.12::.\ARMCLANG)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: FieldOrientedControl_ExampleProject +hex
  c flags: Optim=5 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=6 wLevel=4
  c misc: -fno-exceptions -g
  c include: ..\..\Cdrivers\Headers;.\Drivers\Headers;.\MotorControl\Headers;.\Config\Headers;.\Application\Headers;.\Segger\Headers;.\Middleware\Headers
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x10000 size 0x2000
  scatter file: ..\..\Templates\MCAL.sct
  link misc: --bestdebug --list_mapping_symbols --symbols  --info=summarystack --any_placement=best_fit --diag_suppress L6776W --diag_suppress L6312W --diag_suppress L6314W --diag_suppress L6329W
  group Core
    ./Main/: Main.c
    ./Core/: startup_ARMCM4_89201.s system_ARMCM4.c
  group Config
    ./Config/Sources/: UserParameters.c
    ./Config/Headers/: UserParameters.h
    ./Config/: UserParameters_Guideline.txt
  group Application
    ./Application/Sources/: comm_pwm_app.c
    ./Application/Headers/: comm_pwm_app.h
  group Middleware - Communications
    ./Middleware/Sources/: comm_pwm.c
    ./Middleware/Headers/: comm_pwm.h
  group Drivers - Peripherals
    ./Drivers/Sources/: driver_cau.c driver_dau.c driver_gdu.c driver_gpio.c driver_pwm.c driver_timer.c
    ./Drivers/Headers/: driver_cau.h driver_dau.h driver_gdu.h driver_gpio.h driver_pwm.h driver_timer.h
  group Drivers - MCAL
    ../../Cdrivers/Sources/: Amct.c Cau.c Dau.c Dma.c FlashMemory.c GduMaster.c Gpio.c Gtu.c I2c.c Lin.c PwmGen.c Sci.c Spi.c SystemControl.c SystemTimer.c Uart.c
  group MotorControl - FOC
    ./MotorControl/Sources/: foc_control.c foc_sine_table.c
    ./MotorControl/Headers/: foc_control.h foc_sine_table.h foc_math.h iq_format.h iq_math.h
  group MotorControl - Current Loop
    ./MotorControl/Sources/: foc_current_loop.c
    ./MotorControl/Headers/: foc_current_loop.h
  group MotorControl - Oberver
    ./MotorControl/Sources/: smo_pos.c
    ./MotorControl/Headers/: smo_pos.h
  group MotorControl - Single Shunt & SVPWM
    ./MotorControl/Sources/: single_shunt.c
    ./MotorControl/Headers/: single_shunt.h
  group MotorControl - Speed Loop
    ./MotorControl/Sources/: speed_loop.c
    ./MotorControl/Headers/: speed_loop.h
  group MotorControl - API
    ./MotorControl/Sources/: foc_control_api.c
    ./MotorControl/Headers/: foc_control_api.h
  group Segger
    ./Segger/Headers/: SEGGER_RTT_TEST.h
    ./Segger/Sources/: SEGGER_RTT.c SEGGER_RTT_printf.c
software components: CMSIS:CORE 5.3.0
